# IAR project demoLQ_KV58F24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 Freescale MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050,Pm008
  ICCARM.CCIncludePath2: LQuser/devices/include; LQuser/devices/startup; LQuser/devices; LQuser/drivers/inc; LQuser/drivers/src; LQuser/osa; LQuser/system; LQuser/user; LQuser/utilities; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: demoLQ_KV58F24.hex
  ILINK.IlinkOutputFile: gpio_example.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: LQuser/devices/linker/MKV58F1M0xxx24_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: gpio_example.srec
  ILINK.IlinkIcfFile: LQuser/devices/linker/MKV58F1M0xxx24_flash.icf
  group driver/HSADC
    LQuser/drivers/src/hsadc/: fsl_hsadc_common.c fsl_hsadc_driver.c fsl_hsadc_hal.c
    LQuser/drivers/inc/: fsl_hsadc_driver.h fsl_hsadc_hal.h
  group driver/sysbase
    LQuser/drivers/src/abase/: fsl_dmamux_hal.c fsl_llwu_hal.c fsl_mcg_hal.c fsl_mcg_hal_modes.c fsl_mscm_hal.c fsl_osc_hal.c fsl_port_hal.c fsl_rcm_hal.c fsl_sim_hal_MKV58F24.c fsl_sim_hal_MKV58F24.h fsl_smc_hal.c
  group Processing
    LQuser/user/: APPmain.c filter.c filter.h mathematics.c mathematics.h menu.c menu.h PID.c PID.h PMU.c PMU.h processing.c processing.h
  group startup
    LQuser/devices/startup/: startup.c startup.h startup_MKV58F24.s system_MKV58F24.c system_MKV58F24.h
  group system
    LQuser/system/: fsl_clock_manager.c fsl_clock_manager.h fsl_clock_manager_common.c fsl_clock_MKV58F24.c fsl_clock_MKV58F24.h fsl_hwtimer.c fsl_hwtimer.h fsl_hwtimer_pit.c fsl_hwtimer_pit.h fsl_hwtimer_systick.c fsl_hwtimer_systick.h fsl_hwtimer_systick_irq.c fsl_interrupt_manager.c fsl_interrupt_manager.h fsl_interrupt_manager_common.c fsl_interrupt_manager_irq.c fsl_power_manager.c fsl_power_manager.h fsl_power_manager_common.h pin_mux.c pin_mux.h
    LQuser/devices/: fsl_device_registers.h
  group user
    LQuser/user/: CodingSwitch.c CodingSwitch.h common.h diskio.c diskio.h fatfs.c fatfs.h ff_config.h include.h integer.h L3G4200D.c L3G4200D.h LPTMR.c LPTMR.h LQ12864.h LQ12864SPI.c LQ9AX.c LQ9AX.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_PLL.c LQ_PLL.h LQ_SGP18T.c LQ_SGP18T.h LQADC.c LQADC.h LQDMA.c LQDMA.h LQFTM.c LQFTM.h LQGPIO.c LQGPIO.h LQGPIO_Cfg.h LQI2C.c LQI2C.h LQIIC6050.c LQlogo.h LQMPU6050.h LQMT9V034.c LQMT9V034.h LQPIT.c LQPIT.h LQUART.c LQUART.h LQWDOG.c LQWDOG.h MicroSD.c MicroSD.h simulationIIC.c simulationIIC.h
  group utilities
    LQuser/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_misc_utilities.c fsl_misc_utilities.h print_scan.c print_scan.h
