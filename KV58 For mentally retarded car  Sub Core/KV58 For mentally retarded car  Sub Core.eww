<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KV58 For mentally retarded car  Sub Core.ewp</path>
  </project>
</workspace>


